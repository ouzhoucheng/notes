# Keil uVision project RTOS_ss.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: RTOS_ss
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\Source\include;..\freertos\portable;..\freertos\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group FreeRTOS/Source
    ../freertos/Source/: list.c task.c
    ../freertos/portable/RVDS/ARM_CM3/: port.c
  group doc
    ../Doc/: readme.txt
  group FreeRTOS/include
    ../freertos/Source/include/: FreeRTOSConfig.h list.h portmacro.h rtdef.h FreeRTOS.h include.h
    ../freertos/portable/RVDS/ARM_CM3/: port.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
